# Keil uVision project 8a8k.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 8a8k +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DMP
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c uart.c MPU6050.c iic.c PID.c PWM.c GPIO.c OLED.c speed.c
